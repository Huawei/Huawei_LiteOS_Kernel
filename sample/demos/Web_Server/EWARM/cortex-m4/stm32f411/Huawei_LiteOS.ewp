# IAR project Huawei_LiteOS.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F411RE ST STM32F411RE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: STM32F411xE; USE_STDPERIPH_DRIVER
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\Huawei_LiteOS\platform\bsp\sample\config\include; ..\..\..\..\..\..\Huawei_LiteOS\platform\bsp\sample\config; ..\..\..\..\..\..\Huawei_LiteOS\platform\cpu\arm\cortex-m4; ..\..\..\..\..\..\Huawei_LiteOS\kernel\include; ..\..\..\..\..\..\Huawei_LiteOS\kernel\base\include; ..\..\..\..\..\lib\cortex-m4\Include; ..\..\..\..\..\lib\cortex-m4\STM32F4xx_StdPeriph_Driver\inc; ..\..\..\..\..\lib\cortex-m4\STM32F4xx_StdPeriph_Driver\src; ..\..\..\..\..\lib\cortex-m4\CMSIS\Device\ST\STM32F4xx\Include; ..\..\..\..\..\driver; ..\..\..\..\..\include; ..\..\..\..\..\app; ..\..\..\..\..\demos\Web_Server\EWARM\cortex-m4\stm32f411\user; ..\..\..\..\..\demos\Web_Server\EWARM\cortex-m4\stm32f411\config
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Huawei_LiteOS.bin
  ILINK.IlinkOutputFile: Huawei_LiteOS.out
  ILINK.IlinkIcfFile: Huawei_LiteOS_cortexMF411.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 0
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group app
    ../../../../../app/: ip_arp_udp_tcp.c web_server.c
  group config
    config/: gpio_config.c spi_config.c usart_config.c
  group driver
    ../../../../../driver/: enc28j60_driver.c led_driver.c
  group Huawei_LiteOS/platform/bsp
    ../../../../../../Huawei_LiteOS/platform/bsp/sample/config/: los_config.c
  group Huawei_LiteOS/platform/cpu
    ../../../../../../Huawei_LiteOS/platform/cpu/arm/cortex-m4/: los_dispatch.s los_hw.c los_hw_tick.c los_hwi.c los_vendor.s
  group Huawei_LiteOS/platform/kernel/base
    ../../../../../../Huawei_LiteOS/kernel/base/ipc/: los_event.c los_mux.c los_queue.c los_sem.c
    ../../../../../../Huawei_LiteOS/kernel/base/mem/: los_membox.c los_memory.c los_memstat.c los_multipledlinkhead.c
    ../../../../../../Huawei_LiteOS/kernel/base/misc/: los_misc.c
    ../../../../../../Huawei_LiteOS/kernel/base/core/: los_priqueue.c los_swtmr.c los_sys.c los_task.c los_tick.c los_timeslice.c
  group m4-lib
    ../../../../../lib/cortex-m4/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_spi.c stm32f4xx_usart.c
  group user
    user/: main.c readme.txt
